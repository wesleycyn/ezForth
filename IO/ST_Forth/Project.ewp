# IAR project Project.ewp, settings and files
configuration STM3210E-EVAL (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ; library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM3210E-EVAL.out
  ILINK.IlinkIcfFile: stm32f10x_flash_extsram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCIncludePath2: ..\; ..\..\library\inc
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: STM3210B-EVAL.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  group (top)
    ./: BCorHardWare.h
  group Doc
    ./: readme.txt
  group EWARMv5
    ./: cortexm3_macro.s stm32f10x_flash_extsram.icf stm32f10x_vector.c
  group FWLib
    library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HardWare
    ./: Configuration_DMA.c Configuration_GPIO.c Configuration_NVIC.c Configuration_RCC.c Configuration_RTC.c Configuration_SPI.c Configuration_Timer.c Configuration_USART.c fsmc_nor.c HardWare_1sec.c HardWare_FastFun.c HardWare_Flash.c HardWare_LEDScan.c HardWare_Music.c HardWare_Relay.c HardWare_RTC.c HardWare_USART.c STM32F10x.c stm32f10x_it.c
  group User
    ./: music.cpp
