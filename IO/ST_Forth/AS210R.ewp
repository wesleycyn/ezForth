# IAR project AS210R.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2210 NXP LPC2210
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: AS210R.srec
  ILINK.IlinkOutputFile: AS210R.out
  ILINK.IlinkIcfFile: D:\IAR_ARM\AS210R\AS210R.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: AS210R.mot
  ILINK.IlinkIcfFile: D:\wesley\AS210R(Convert_Show)_20081209am1035\AS210R.icf
  group (top)
    ./: AS210R.icf AS210R_main.c BCorLPC2210.h Decompression.c Flash.c led_effect.cpp LPC2210.c lpc2xxx_cstartup_Jmp2IRQ.s music.cpp SelfTest.cpp Unit1.cpp upgrade.cpp
